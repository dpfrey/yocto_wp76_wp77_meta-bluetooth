IMAGE_INSTALL += "bluez5"
IMAGE_INSTALL += "ti-wl18xx-bt-firmware"
